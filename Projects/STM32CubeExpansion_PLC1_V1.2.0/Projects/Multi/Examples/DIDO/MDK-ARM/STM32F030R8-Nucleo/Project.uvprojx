# Keil uVision project Project.uvprojx, settings and files
target DIDO (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STM32F0XX_NUCLEO,USE_HAL_DRIVER,STM32F030x8,USE_HAL_LEGACY
  c misc: --C99
  c include: ..\..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_PLC01A1;..\..\..\..\..\..\Drivers\BSP\Components\VNI8200XP;..\..\..\..\..\..\Drivers\CMSIS\Include\;..\..\..\..\..\..\Drivers\BSP\STM32F0xx_Nucleo;..\..\..\..\..\..\Drivers\BSP\Components\CLT01_38SQ7
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Src
    ../../Src/: cube_hal_f0.c main.c stm32f0xx_hal_msp.c stm32f0xx_it.c
  group Drivers/BSP/Components/
    ../../../../../../Drivers/BSP/Components/VNI8200XP/: vni8200xp.c
    ../../../../../../Drivers/BSP/Components/CLT01_38SQ7/: clt01_38s.c
  group Drivers/BSP/STM32F0xx_Nucleo
    ../../../../../../Drivers/BSP/STM32F0xx_Nucleo/: stm32f0xx_nucleo.c
  group Drivers/BSP/X_NUCLEO_PLC01A1
    ../../../../../../Drivers/BSP/X_NUCLEO_PLC01A1/: x_nucleo_plc01a1.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_can.c stm32f0xx_hal_cec.c stm32f0xx_hal_comp.c stm32f0xx_hal_cortex.c stm32f0xx_hal_crc.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_dac.c stm32f0xx_hal_dac_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_i2s.c stm32f0xx_hal_irda.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_smartcard.c stm32f0xx_hal_smartcard_ex.c stm32f0xx_hal_smbus.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_tsc.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_hal_wwdg.c
  group Example/MDK-ARM
    ./: startup_stm32f030x8.s
  group Doc
    ../../: readme.txt
