# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030R8 ST STM32F030R8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F030x8; USE_STM32F0XX_NUCLEO; USE_HAL_DRIVER; USE_HAL_LEGACY
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F0xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_PLC01A1; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\CLT01_38SQ7; ..\..\..\..\..\..\Drivers\BSP\Components\VNI8200XP
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DIDO.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f030x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/CLT01_38SQ7/: clt01_38s.c
    ../../../../../../Drivers/BSP/Components/VNI8200XP/: vni8200xp.c
  group Drivers/BSP/STM32F0xx_Nucleo
    ../../../../../../Drivers/BSP/STM32F0xx_Nucleo/: stm32f0xx_nucleo.c
  group Drivers/BSP/X_NUCLEO_PLC01A1
    ../../../../../../Drivers/BSP/X_NUCLEO_PLC01A1/: x_nucleo_plc01a1.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_spi.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
  group Examples/EWARM
    ./: startup_stm32f030x8.s
  group Examples/User
    ../../Src/: cube_hal_f0.c main.c stm32f0xx_hal_msp.c stm32f0xx_it.c
