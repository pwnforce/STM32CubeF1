# Keil uVision project Project.uvprojx, settings and files
target DIDO (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F401xE,USE_STM32F4XX_NUCLEO,USE_HAL_DRIVER
  c include: ..\..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F4xx_Nucleo;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_PLC01A1;..\..\..\..\..\..\Drivers\BSP\Components\CLT01_38SQ7;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\VNI8200XP;..\..\..\..\..\..\Drivers\CMSIS\Include\
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Drivers\BSP\Components
    ../../../../../../Drivers/BSP/Components/CLT01_38SQ7/: clt01_38s.c
    ../../../../../../Drivers/BSP/Components/VNI8200XP/: vni8200xp.c
  group Drivers\BSP\STM32F4xx_Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx_Nucleo/: stm32f4xx_nucleo.c
  group Drivers\BSP\X_NUCLEO_PLC01A1
    ../../../../../../Drivers/BSP/X_NUCLEO_PLC01A1/: x_nucleo_plc01a1.c
  group Drivers\CMSIS
    ../../Src/: system_stm32f4xx.c
  group Drivers\STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c stm32f4xx_hal_dsi.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc_ex.c
  group Examples\MDK
    ./: startup_stm32f401xe.s
  group Examples\User
    ../../Src/: cube_hal_f4.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Doc
    ../../: readme.txt
